# Keil uVision project BBear_FreeRTOS_demo.uvproj, settings and files
target FreeRTOS (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BBear_FreeRTOS_demo +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER  STM32F10X_MD
  c include: ..\lib\CMSIS\CM3\CoreSupport;..\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\lib\STM32F10x_StdPeriph_Driver\inc;..\source_code;..\source_code\FreeRTOS\Common\include;..\source_code\FreeRTOS\Source\include;..\source_code\FreeRTOS\Source\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../source_code/: main.c
  group FreeRTOS
    ../source_code/FreeRTOS/Source/: list.c queue.c tasks.c croutine.c event_groups.c timers.c
    ../source_code/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../source_code/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group lib
    ../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
